options:
  parameters:
    author: Michael Mann
    generate_options: qt_gui
    id: opal_vanguard_loopback
    output_language: python
    title: Opal Vanguard Full Loopback
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tx15/opal-vanguard/ov1_c0_s2m.cf32
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: depacketizer
  id: opal_vanguard_depacketizer
  parameters:
    use_fec: 'True'
  states: {}
- name: gfsk_demod
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {}
- name: gfsk_mod
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {}
- name: hop_ctrl
  id: opal_vanguard_lfsr_hop_generator
  parameters:
    center_freq: center_freq
    channel_spacing: 50e3
    num_channels: '50'
    seed: '0xACE'
  states: {}
- name: hop_timer
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '200'
  states: {}
- name: import_path
  id: import
  parameters:
    imports: import sys; import os; sys.path.append(os.path.join(os.path.dirname(os.path.abspath('__file__')), '../src'))
  states: {}
- name: msg_print_rx
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: msg_to_rot_rx
  id: opal_vanguard_msg_to_rotator
  parameters:
    center_freq: center_freq
    invert: 'True'
    rotator: '"rot_rx"'
    samp_rate: samp_rate
  states: {}
- name: opal_vanguard_msg_to_rotator_0
  id: opal_vanguard_msg_to_rotator
  parameters:
    center_freq: center_freq
    invert: 'False'
    rotator: '"rot_tx"'
    samp_rate: samp_rate
  states: {}
- name: packetizer
  id: opal_vanguard_packetizer
  parameters:
    use_fec: 'True'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(len("Opal Vanguard"), list("Opal Vanguard".encode())))
    period: '1000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX Frequency View"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Bits
    name: '"Recovered Bits"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rot_rx
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0'
  states: {}
- name: rot_tx
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0'
  states: {}
- name: unpacker
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', rot_rx, '0']
- [depacketizer, out, msg_print_rx, print]
- [gfsk_demod, '0', blocks_char_to_float_0, '0']
- [gfsk_demod, '0', depacketizer, '0']
- [gfsk_mod, '0', rot_tx, '0']
- [hop_ctrl, freq, msg_to_rot_rx, msg]
- [hop_ctrl, freq, opal_vanguard_msg_to_rotator_0, msg]
- [hop_timer, strobe, hop_ctrl, trigger]
- [packetizer, out, blocks_message_debug_0, print]
- [packetizer, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', unpacker, '0']
- [pdu_strobe, strobe, packetizer, in]
- [rot_rx, '0', blocks_file_sink_0, '0']
- [rot_rx, '0', gfsk_demod, '0']
- [rot_tx, '0', blocks_throttle_0, '0']
- [unpacker, '0', gfsk_mod, '0']

metadata:
  file_format: 1
